# IAR project stack_monitor.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F411xE
  ICCARM.CCIncludePath2: ..\drivers\STM32F4xx_HAL_Driver\Inc; ..\drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\drivers\CMSIS\Include; ..\drivers\CMSIS\Device\ST\STM32F4xx\Include; $PROJ_DIR$; ..\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: freertos-examples.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\drivers\CMSIS\Device\ST\STM32F4xx\Source\Templates\iar\linker\stm32f411xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group application
    ./: app.c cli.c main.c stack_monitor.c stm32f4xx_it.c uart_app.c
    ../common/: init.c
  group drivers/cmsis
    ../drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f411xe.s
    ../drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group drivers/stm32
    ../drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c
